# Keil uVision project hello_world.uvprojx, settings and files
target hello_world (5060960::V5.06 update 7 (build 960)::.\ARMCOMPILER5)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: hello_world +hex
  AfterMake: fromelf --bin .\Objects\hello_world.axf -o .\Objects\hello_world.bin
  AfterMake: fromelf -cvf .\Objects\hello_world.axf -o .\Objects\disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: hello_world.c
  group drv
    ../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c calibrate_interrupt.c calibrate_interrupt.h
